options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '-60'
    step: '1'
    stop: '30'
    value: '-20'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(volume/20)
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0, 1)
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2)
    size: '1024'
    srate: samp_rate
    type: float
    width1: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: (0, 0)
    type: complex
    update_time: '0.01'
    wintype: window.WIN_HANN
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_agc2_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_agc2_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc2_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_am_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', analog_agc2_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
